Commit message: Stripped out everything not related to the hand itself.

File: lyra_gz/models/hand_module.urdf (robot description, URDF)
Before this commit: robot mpl_haptix_right_forearm, 15 links, 15 joints
Links:
- added link world, mass 0.01
Joints:
- joint wristy: parent arm_link -> world
